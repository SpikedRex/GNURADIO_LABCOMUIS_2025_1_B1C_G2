options:
  parameters:
    author: Danilo_Duran
    category: '[Modulos Danilo]'
    copyright: UIS
    generate_options: hb
    id: ModuladorAM_1A_Gx
    output_language: python
    run: 'False'
    title: ModuladorAM_1A_Gx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Ac
  id: parameter
  parameters:
    label: Amplitud portadora
    type: eng_float
    value: '1'
  states: {}
- name: add_const
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: float_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: ka
  id: parameter
  parameters:
    label: coeficiente ka
    type: eng_float
    value: '1'
  states: {}
- name: multiply_const
  id: blocks_multiply_const_vxx
  parameters:
    const: ka
    type: float
  states: {}
- name: multiplyconst
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: null_source
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: pad_sink
  id: pad_sink
  parameters:
    label: s(t)
    type: complex
  states: {}
- name: pad_source
  id: pad_source
  parameters:
    label: m(t)
    type: float
  states: {}

connections:
- [add_const, '0', float_to_complex, '0']
- [float_to_complex, '0', multiplyconst, '0']
- [multiply_const, '0', add_const, '0']
- [multiplyconst, '0', pad_sink, '0']
- [null_source, '0', float_to_complex, '1']
- [pad_source, '0', multiply_const, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
